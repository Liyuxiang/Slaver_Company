# IAR project Slaver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL16Z64xxx4 Freescale MKL16Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Include; ..\MKL16Z4; ..\MKL16Z4\include; ..\MKL16Z4\startup
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Slaver.srec
  ILINK.IlinkOutputFile: Slaver.out
  ILINK.IlinkIcfFile: E:\Slaver\MKL16Z4\linker\iar\MKL16Z64xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Driver
    ../Driver/: MKL_gpio.c MKL_spi.c MKL_uart.c retarget_iar.c w25x32.c
  group Startup
    ../MKL16Z4/: startup.c
    ../MKL16Z4/startup/iar/: startup_MKL16Z4.s
    ../MKL16Z4/startup/: system_MKL16Z4.c
  group User
    ../User/: main.c
